# Keil uVision project RM_Infantry_2022.uvprojx, settings and files
target RM_Infantry_2022 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: RM_Infantry_2022 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__CC_ARM,__TARGET_FPU_VFP=1
  c misc: --cpp11
  c include: ../Core/Inc;      ../Drivers/STM32F4xx_HAL_Driver/Inc;      ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;      ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;      ../Drivers/CMSIS/Include;      ../Middlewares/Third_Party/FreeRTOS/Source/include;      ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;      ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;      ..\GRWML;      ..\GRWML\Drivers\Components;      ..\GRWML\Drivers\Devices;      ..\GRWML\Middlewares;      ..\GRWML\Middlewares\Algorithm;      ..\User_Core;      ..\User_Core\Application;      ..\User_Core\Application\Tasks;      ..\User_Core\Components;      ..\User_Core\Devices;      ..\User_Core\Middlewares;      ..\User_Core\Module;      ..\User_Core\Module\Control;      ..\User_Core\Middlewares\User_Algorithm;      ..\Drivers\CMSIS\DSP\Include;      ..\User_Core\Application\Tasks;      ..\User_Core\Devices\BMI088_EKF;      ..\kalman_hpz;     ../USB_DEVICE/App;     ../USB_DEVICE/Target;     ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;     ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Middlewares/Algorithm
    ../GRWML/Middlewares/Algorithm/: PID.cpp Filter.cpp Ramp.cpp
  group Drivers/Componets
    ../GRWML/Drivers/Components/: BSP_CAN.c BSP_UART.c BSP_FLASH.c
  group Drivers/Devices
    ../GRWML/Drivers/Devices/: DR16.cpp Motor.h
  group User_Core/Application
    ../User_Core/Application/: Robot_Config.cpp System_Config.cpp System_DataPool.cpp
    ../User_Core/: GRWML_Config.h
  group User_Core/Application/Tasks
    ../User_Core/Application/Tasks/: Task_Init.cpp Task_CAN.cpp Task_DR16.cpp Task_Control.cpp Task_Vision.cpp Task_Referee.cpp Task_Monitor.cpp Task_LED.cpp Task_IMU.cpp
  group User_Core/Module
    ../User_Core/Module/: Communication.cpp Devices_Monitor.cpp
    ../User_Core/Application/Tasks/: Task_Debug.cpp
  group User_Core/Control
    ../User_Core/Module/Control/: Control_DR16.cpp Control_Gimbal.cpp Control_Robot.cpp Control_Shoot.cpp Control_Chassis.cpp Control_Vision.cpp SolveTrajectory.cpp
  group User_Core/Devices
    ../User_Core/Devices/: SerialDebug.cpp Dev_Buzzer.cpp Dev_IMU.cpp Dev_LED.cpp Dev_OLED.cpp ANO.c
  group User_Core/Devices/BMI088_EKF
    ../User_Core/Devices/BMI088_EKF/: INS_EKF_task.c BMI088driver.c BMI088Middleware.c QuaternionEKF.c kalman_filter_IMU.c bsp_dwt.c
  group User_Components
    ../User_Core/Components/: BSP_PVD.c BSP_SPI.c BSP_ADC.c
  group User_Algorithm
    ../User_Core/Middlewares/User_Algorithm/: kalman_Filter.cpp Slope_Filter.cpp
  group kalman_hpz
    ../kalman_hpz/: kalman_hpz.cpp
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
